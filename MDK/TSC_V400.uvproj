# Keil uVision project TSC_V400.uvproj, settings and files
target Project_RAM (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TSC_V400 +hex
  c flags: Optim=1 OneElfS=1
  c define: VECT_TAB_RAM
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\User;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\MDK;..\Libraries;..\app;..\enc28j60;..\lwip-1.4.1;..\lwip-1.4.1\arch;..\lwip-1.4.1\lwip-1.4.1\src\include;..\lwip-1.4.1\lwip-1.4.1\src\include\ipv4;..\lwip-1.4.1\lwip-1.4.1\src\include\netif;..\lwip-1.4.1\lwip-1.4.1\src\include\lwip;..\lwip-1.4.1\lwip-1.4.1\src\api;..\lwip-1.4.1\lwip-1.4.1\src\core;..\lwip-1.4.1\lwip-1.4.1\src\core\ipv4;..\lwip-1.4.1\lwip-1.4.1\src\core\snmp;..\lwip-1.4.1\lwip-1.4.1\src\netif;..\lwip-1.4.1\arch\junk;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xc000
  memory RVCT9: RAM 0x2000c000 size 0x4000
  group Scrs
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_systick.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group lwip-api
    ./lwip-1.4.1/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-core
    ./lwip-1.4.1/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip-core-ipv4
    ./lwip-1.4.1/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip-core-snmp
    ./lwip-1.4.1/lwip-1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
  group lwip-netif
    ./lwip-1.4.1/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group enc28j60
    ./enc28j60/: ENC28J60.C
  group netapp
    ./app/: tcp_client.c tcp_server.c app_hooks.c
  group ucos-core
    ./uCOS-II/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos-port
    ./uC-Ports/ARM-Cortex-M3/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group User
    ./: main.c Sys_Config.c Delay.c Ex_Var.c KEY_OP.c LED_OP.c TIME_OP.c USART_OP.c E2PROM_OP.c RA8806_CTRL.c Menu_Resource.c at24c64_op.c ds1302_op.c cpu_cfg.h includes.h lib_cfg.h os_cfg.h
    ./User/: netconf.c SPI_OP.c
  group Ext
    ./: stm32f10x_it.c
target Project_FLASH (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: TSC_V400 +hex
  c flags: Optim=1 OneElfS=1
  c define: LWIP_COMPAT_MUTEX
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\User;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\MDK;.\app;.\enc28j60;.\User;.\lwip-1.4.1;.\lwip-1.4.1\arch;.\lwip-1.4.1\lwip-1.4.1\src\include;.\lwip-1.4.1\lwip-1.4.1\src\include\ipv4;.\lwip-1.4.1\lwip-1.4.1\src\include\netif;.\lwip-1.4.1\lwip-1.4.1\src\include\lwip;.\lwip-1.4.1\lwip-1.4.1\src\api;.\lwip-1.4.1\lwip-1.4.1\src\core;.\lwip-1.4.1\lwip-1.4.1\src\core\ipv4;.\lwip-1.4.1\lwip-1.4.1\src\core\snmp;.\lwip-1.4.1\lwip-1.4.1\src\netif;.\lwip-1.4.1\arch\junk;.\uC-LIB;.\uC-Ports;.\uC-Ports\ARM-Cortex-M3;.\uCOS-II
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
